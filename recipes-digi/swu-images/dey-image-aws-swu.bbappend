# Copyright (C) 2021 Digi International Inc.

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

require dualboot.inc
