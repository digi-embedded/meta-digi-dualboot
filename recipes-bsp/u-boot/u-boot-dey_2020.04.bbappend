# Copyright (C) 2021 Digi International

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

COMPATIBLE_MACHINE = "(ccimx8x|ccimx8m|ccimx6ul)"
