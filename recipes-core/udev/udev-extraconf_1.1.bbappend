# Copyright (C) 2021 Digi International.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

